File: pcb/fpga-gb-framebuffer.kicad_pcb (KiCad board)
At the start: 2 copper layers, 73.7 x 45.7 mm, 20 parts

Commit message: refresh pcb with newer kikad
Other:
- net class Default removed
